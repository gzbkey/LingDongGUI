# Keil uVision project mh2103c.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: AIR32F103CC Generic
  pack: Keil.AIR32F103_DFP.1.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mh2103c
  AfterMake: E:\ldgui\LingDongGUI\examples\mh2103c\keil5_disp_size_bar.exe
  c flags: Optim=5 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: .\user;.\Libraries\MH210xLib\inc;.\Libraries\MH210xLib\lib;.\user\driver;..\..\src\gui;..\..\src\misc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./user/: main.c Retarget.c ldConfig.c ldUser.c image.c
  group lib/lib
    ./Libraries/MH210xLib/lib/: mh2103.lib
    ./Libraries/MH210xLib/src/: mh210x_adc.c mh210x_bkp.c mh210x_can.c mh210x_crc.c mh210x_dac.c mh210x_dbgmcu.c mh210x_dma.c mh210x_exti.c mh210x_flash.c mh210x_fsmc.c mh210x_gpio.c mh210x_i2c.c mh210x_iwdg.c mh210x_otp.c mh210x_pwr.c mh210x_rcc.c mh210x_rtc.c mh210x_sdio.c mh210x_spi.c mh210x_tim.c mh210x_trng.c mh210x_usart.c mh210x_wwdg.c misc.c system_mh210x.c
  group lib/core
    ./Libraries/CORE/: startup_mh210x.s
  group user/driver
    ./user/driver/: st7789v16bit.c
  group ldgui/gui
    ../../src/gui/: ldArc.c ldButton.c ldCheckBox.c ldComboBox.c ldCommon.c ldDateTime.c ldGauge.c ldGraph.c ldGui.c ldIconSlider.c ldImage.c ldKeyboard.c ldLabel.c ldLineEdit.c ldProgressBar.c ldQRCode.c ldRadialMenu.c ldScene0.c ldScrollSelecter.c ldTable.c ldText.c ldWindow.c
  group ldgui/misc
    ../../src/misc/: freeRtosHeap4.c qrcodegen.c tlsf.c xBtnAction.c xConnect.c xList.c xQueue.c xString.c
software components: Acceleration:Arm-2D Extras:Controls 1.5.7, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.1.1, Acceleration:Arm-2D Helper:Display Adapter 1.8.3, Acceleration:Arm-2D Helper:PFB 1.8.4, Acceleration:Arm-2D:Alpha-Blending 1.1.5, Acceleration:Arm-2D:Core 1.1.5, Acceleration:Arm-2D:Transform 1.1.6, CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.0, Utilities:perf_counter:Core 2.2.3
