# Keil uVision project fastModel.uvprojx, settings and files
target CM4 (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fastModel
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: __USE_FVP__,NDEBUG,__ARM_2D_HAS_ANTI_ALIAS_TRANSFORM__=1,__ARM_2D_CFG_SUPPORT_COLOUR_CHANNEL_ACCESS__=1,
  c include: .\user;.\user\drivers;.\user\drivers\mps2;..\..\src\gui;..\..\src\misc
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\RTE\Device\CMSDK_CM4_FP\mps2.sct
  link misc: --entry=Reset_Handler --diag_suppress=6314,6329
  group user
    ./user/: main.c arm_2d_scene_0.c ldUser.c
  group user/drivers
    ./user/drivers/mps2/: GLCD_V2M-MPS2.c
    ./user/drivers/mps3/: GLCD_V2M-MPS3_AN540.c
  group ldGui/gui
    ../../src/gui/: ldCommon.c ldImage.c ldGui.c ldWindow.c
  group ldGui/misc
    ../../src/misc/: xConnect.c xList.c xQueue.c xString.c freeRtosHeap4.c
target CM55 (6190000::V6.19::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.3.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00100000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: fastModel
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: NDEBUG,LCD_MIRROR_X=1,GLCD_MIRROR_Y=0,__USE_AN547__,__ARM_2D_HAS_ANTI_ALIAS_TRANSFORM__=1
  c include: .\user;.\user\drivers;.\user\drivers\mps3;..\..\src\gui;..\..\src\misc
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x100000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler --diag_suppress=6314,6329
software components: Acceleration:Arm-2D Extras:Controls 1.4.2, Acceleration:Arm-2D Extras:LCD ASCII Printf 1.3.1, Acceleration:Arm-2D Helper:Display Adapter 1.6.2, Acceleration:Arm-2D Helper:PFB 1.6.7, Acceleration:Arm-2D:Alpha-Blending 1.1.3, Acceleration:Arm-2D:Core 1.1.4, Acceleration:Arm-2D:Transform 1.1.3, CMSIS:CORE 5.6.0, CMSIS:DSP 1.14.2, Device:Definition 1.2.0, Device:Startup 1.2.0, Native Driver:SysCounter 1.1.0, Native Driver:SysTimer 1.1.0, Native Driver:Timeout 1.0.0, Utilities:perf_counter:Core 2.1.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.1.0
