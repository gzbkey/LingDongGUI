# Keil uVision project stm32f103.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,IP=IPR
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c
software components: Acceleration:Arm-2D Extras:Controls 1.8.3, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.6.2, Acceleration:Arm-2D Helper:PFB 2.1.8, Acceleration:Arm-2D:Alpha-Blending 1.1.7, Acceleration:Arm-2D:Core 1.1.7, Acceleration:Arm-2D:Filter 1.1.7, Acceleration:Arm-2D:Transform 1.1.7, CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Utilities:perf_counter:Core 2.3.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, LingDongGui Demo:startup 1.0.0, LingDongGui:ldgui 0.8.0
